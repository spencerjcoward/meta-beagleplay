FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-update-bootcmd.patch"
SRC_URI += "file://0002-update-boot0-offsets.patch"
